# Keil uVision project BH-F103.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,DEBUG_ENABLE_SEMIHOST
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\AdvanceTim;..\..\User\flash;..\..\User\font;..\..\User\GPIO;..\..\User\lcd;..\..\User\SysTick;..\..\User\USART;..\..\User\Move;..\..\User\I2C;..\..\User\mpu6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/font/: fonts.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/SysTick/: systick.c
    ../../User/GPIO/: GPIO.c
    ../../User/AdvanceTim/: AdvanceTim.c
    ../../User/USART/: usart.c
    ../../User/Move/: Move.c
    ../../User/I2C/: I2C.c
    ../../User/mpu6050/: mpu6050.c
  group DOC
    ../../Doc/: readme.txt
